options:
  parameters:
    generate_options: qt_gui
    id: MIMO_alamouti_rx
    output_language: python
    title: MIMO_alamouti_rx
  states: {}

blocks:
- name: centre_fre
  id: variable
  parameters:
    value: 0.9e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0]'
  states: {}
- name: sync_word3
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0]'
  states: {}
- name: sync_word4
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0]'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/li/桌面/complex.bin
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/li/桌面/byte.bin
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters: {}
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '10'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '9'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    name: '1'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '2'
    size: '1024'
    type: complex
    ymax: '0.06'
    ymin: '-0.06'
  states: {}
- name: qtgui_const_sink_x_0_1_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '3'
    size: '1024'
    type: complex
    ymax: '0.06'
    ymin: '-0.06'
  states: {}
- name: qtgui_const_sink_x_0_1_0_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '1'
    size: '1024'
    type: complex
    ymax: '0.06'
    ymin: '-0.06'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '13'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '14'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: tutorial_2_estimation_mod_cc_0
  id: tutorial_2_estimation_mod_cc
  parameters:
    estimation_mod: ''
    symbols: ''
  states: {}
- name: tutorial_3_detagmod_cc_0
  id: tutorial_3_detagmod_cc
  parameters:
    detag_mod: ''
    symbols: ''
  states: {state: disabled}
- name: tutorial_3_detagmod_cc_1
  id: tutorial_3_detagmod_cc
  parameters:
    detag_mod: ''
    symbols: ''
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: '800000'
    bw1: '800000'
    center_freq0: centre_fre
    center_freq1: centre_fre
    clock_rate: 184.32e6
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [tutorial_2_estimation_mod_cc_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [tutorial_2_estimation_mod_cc_0, '0', qtgui_const_sink_x_0_1_0_0_1, '0']
- [tutorial_2_estimation_mod_cc_0, '0', tutorial_3_detagmod_cc_0, '0']
- [tutorial_2_estimation_mod_cc_0, '0', tutorial_3_detagmod_cc_1, '0']
- [tutorial_2_estimation_mod_cc_0, '1', qtgui_const_sink_x_0_1_0_0, '0']
- [tutorial_3_detagmod_cc_1, '0', blocks_file_sink_0, '0']
- [tutorial_3_detagmod_cc_1, '0', digital_constellation_decoder_cb_0, '0']
- [tutorial_3_detagmod_cc_1, '0', qtgui_const_sink_x_0_1_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', tutorial_2_estimation_mod_cc_0, '0']
- [uhd_usrp_source_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '1', tutorial_2_estimation_mod_cc_0, '1']

metadata:
  file_format: 1
